# Keil uVision project LLLT.uvprojx, settings and files
target N32G031 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G031K8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LLLT +hex
  AfterMake: fromelf --bin --output=.\bin\LLLT.bin .\Objects\LLLT.axf
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G031, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\..\bsp\inc;..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32g031_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32g031.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32g031.c
  group FWLIB
    ../../firmware/n32g031_std_periph_driver/src/: misc.c n32g031_adc.c n32g031_gpio.c n32g031_rcc.c n32g031_spi.c n32g031_sqrt.c n32g031_tim.c n32g031_usart.c n32g031_it.c
  group USER
    ../../bsp/src/: adc.c gpio.c key.c main.c timer.c usart.c pwm.c user.c delay.c nec.c
